# KCrash enables X11 integration on Linux when Qt has XCB support.
DEPENDS:append = " libx11"
