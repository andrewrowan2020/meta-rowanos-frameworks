# The legacy DX9 DLL fallback is offered only on the tested D16 target.
COMPATIBLE_MACHINE = "^genio-1200-radxa-nio-12l-d16$"
