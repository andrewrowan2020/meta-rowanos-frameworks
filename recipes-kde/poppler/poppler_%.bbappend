FILESEXTRAPATHS:prepend := "${THISDIR}/poppler:"

SRC_URI += "file://0001-qt6-fix-smart-pointer-backport-types.patch"
