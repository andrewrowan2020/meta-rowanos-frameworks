# SPDX-FileCopyrightText: 2026 RowanOS contributors
# SPDX-License-Identifier: MIT
CONFLICT_DISTRO_FEATURES:remove = "x11"
