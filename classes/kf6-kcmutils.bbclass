# SPDX-FileCopyrightText: 2026 RowanOS contributors
# SPDX-License-Identifier: MIT
inherit kf6_kcmutils
