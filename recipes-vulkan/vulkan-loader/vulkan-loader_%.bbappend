# DXVK's X11 presentation path needs Xlib and Xcb Vulkan surface support.
PACKAGECONFIG:append:genio-1200-radxa-nio-12l-d16 = " x11 "
