# D16 Panfrost supplies X11/DRI3 acceleration for Gamescope's Xwayland.
PACKAGECONFIG:append:genio-1200-radxa-nio-12l-d16 = " panfrost x11 dri3 "
